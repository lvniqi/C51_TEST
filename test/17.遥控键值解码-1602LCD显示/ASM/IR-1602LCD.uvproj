# Keil uVision project IR-1602LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: IR-1602LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: IR-1602LCD.asm
