# Keil uVision project DS1302.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC89C52RC STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: DS1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 DS1302时钟芯片实验2.C
