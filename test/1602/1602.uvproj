# Keil uVision project 1602.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC89C52RC STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 idpdt_key.h key.h led_4.h main.c normal.h timer.h Iic.h At24.h
